<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\udisk_mp3.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>host_msd_fatfs_bm</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
            <member>
                <project>host_msd_fatfs_bm</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_debug</name>
            <member>
                <project>host_msd_fatfs_bm</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_release</name>
            <member>
                <project>host_msd_fatfs_bm</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
