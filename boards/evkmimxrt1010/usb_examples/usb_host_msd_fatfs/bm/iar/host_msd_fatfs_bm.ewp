# IAR project host_msd_fatfs_bm.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1011xxx5A NXP MIMXRT1011xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USB_STACK_USE_NONCACHE_SECTION=1; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1011DAE5A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1; OCRAM_IS_SHAREABLE; ARM_MATH_CM7; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/fatfs/source; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/fatfs/source; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/xip; ../../../../xip; ../../../../../../devices/MIMXRT1011/utilities/str; ../../../../../../devices/MIMXRT1011/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../devices/MIMXRT1011/drivers; ../../../../../devices/MIMXRT1011/drivers; ../../../../../devices/MIMXRT1011/xip; ../../../xip; ../../../../../../middleware/emwin/emWin_Config; ../../../../../../middleware/emwin/emWin_header; ../../../../../../components/ili9341; ../../../../../../components/ft6x06; ../../../../../../devices/MIMXRT1011/cmsis_drivers; ../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: host_msd_fatfs_bm.bin
  ILINK.IlinkOutputFile: host_msd_fatfs_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor_ocram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../middleware/emwin/emWin_library/IAR/emWin_M4F.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 7
  ICCARM.CCDefines: USB_STACK_USE_NONCACHE_SECTION=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1011DAE5A; USB_STACK_BM; PRINTF_ADVANCED_ENABLE=1
  ICCARM.CCIncludePath2: ..; ../../../../../../middleware/fatfs/source; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../middleware/usb/host; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/usb/host/class; ../../../../../../middleware/fatfs/source; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/drivers; ../../../../../../devices/MIMXRT1011/xip; ../../../../xip; ../../../../../../devices/MIMXRT1011/utilities/str; ../../../../../../devices/MIMXRT1011/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../components/lists
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1011xxxxx_flexspi_nor_ocram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h emwin_support.c emwin_support.h pin_mux.c pin_mux.h RTE_Device.h
  group CMSIS
    ../../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group CMSIS_driver
    ../../../../../../CMSIS/Driver/Include/: Driver_Common.h Driver_I2C.h Driver_SPI.h
  group codec
    ../: fsl_codec_common.c fsl_codec_common.h fsl_wm8960.c fsl_wm8960.h
  group component/lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../../components/uart/: lpuart_adapter.c uart.h
  group device
    ../../../../../../devices/MIMXRT1011/: fsl_device_registers.h MIMXRT1011.h MIMXRT1011_features.h system_MIMXRT1011.c system_MIMXRT1011.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1011/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h
    ../../../../../../devices/MIMXRT1011/cmsis_drivers/: fsl_lpi2c_cmsis.c fsl_lpi2c_cmsis.h fsl_lpspi_cmsis.c fsl_lpspi_cmsis.h
  group emwin/emWin_Config
    ../../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group emwin/emWin_Header
    ../../../../../../middleware/emwin/emWin_header/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group fatfs/source
    ../../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group LCD
    ../../../../../../components/ili9341/: fsl_ili9341.c fsl_ili9341.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group source
    ../: app.c app.h ffconf.h fsl_usb_disk.h fsl_usb_disk_bm.c host_msd_fatfs.c host_msd_fatfs.h mp3_config.h usb_host_config.h
  group source/mp3
    ../mp3/helix/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3common.h mp3dec.c mp3dec.h mp3tabs.c mpadecobjfixpt.h scalfact.c statname.h stproc.c subband.c trigtabs.c
    ../mp3/helix/arm/: hylix_mp3_asm.a
    ../mp3/: mp3play.c mp3play.h
  group startup
    ../../../../../../devices/MIMXRT1011/iar/: startup_MIMXRT1011.s
  group touch
    ../../../../../../components/ft6x06/: fsl_ft6x06.c fsl_ft6x06.h
  group usb/host
    ../../../../../../middleware/usb/host/: usb_host.h usb_host_devices.c usb_host_devices.h usb_host_ehci.c usb_host_ehci.h usb_host_framework.c usb_host_framework.h usb_host_hci.c usb_host_hci.h
  group usb/host/class
    ../../../../../../middleware/usb/host/class/: usb_host_hub.c usb_host_hub.h usb_host_hub_app.c usb_host_hub_app.h usb_host_msd.c usb_host_msd.h usb_host_msd_ufi.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../devices/MIMXRT1011/utilities/: fsl_assert.c
    ../../../../../../devices/MIMXRT1011/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1011/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../xip/: evkmimxrt1010_flexspi_nor_config.c evkmimxrt1010_flexspi_nor_config.h evkmimxrt1010_sdram_ini_dcd.c evkmimxrt1010_sdram_ini_dcd.h
    ../../../../../../devices/MIMXRT1011/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
